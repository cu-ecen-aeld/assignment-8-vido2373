## base_external/package/aesd-device-driver/Config.in
```kconfig
config BR2_PACKAGE_AESD_DEVICE_DRIVER
	bool "aesd-device-driver"
	help
	  Includes aesd-char-driver kernel modules
```
